File: Wimshurst.kicad_pcb (KiCad board)
At the start: 2 copper layers, 406.4 x 406.4 mm, 4 parts

Commit message: 32極配置
Other:
- board text added: "ウィムズハースト 誘導起電機"
